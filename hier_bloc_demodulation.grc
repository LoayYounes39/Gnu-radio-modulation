options:
  parameters:
    generate_options: hb
    id: new_hier
    output_language: python
    title: bloc_demodulation
  states: {}

blocks:
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: signal démodulé
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: porteuse
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: signal_modulé
    type: complex
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_conjugate_cc_0, '0']
- [pad_source_1, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
