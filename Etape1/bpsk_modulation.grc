options:
  parameters:
    author: hp
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Bloc de modulation BPSK"""

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='BPSK Modulator',
                  in_sig=[np.uint8],
                  out_sig=[np.complex64]
              )

          def work(self, input_items, output_items):
              """Convertit les bits en symboles BPSK"""
              bits = input_items[0]
              out = output_items[0]
              
              # BPSK : bit 0 -> +1, bit 1 -> -1
              for i in range(len(bits)):
                  if bits[i] == 0:
                      out[i] = complex(1.0, 0.0)
                  else:
                      out[i] = complex(-1.0, 0.0)
              
              return len(bits)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
