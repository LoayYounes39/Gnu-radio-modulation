options:
  parameters:
    generate_options: hb
    id: mod1
    output_language: python
    title: bloc_modulation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/symbol_rate)
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: signal_mod
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: symboles_mod
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: porteuse
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: symboles
    type: complex
  states: {}

connections:
- [blocks_multiply_xx_0_1, '0', pad_sink_1, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_repeat_0, '0', pad_sink_2, '0']
- [pad_source_0, '0', blocks_multiply_xx_0_1, '0']
- [pad_source_0_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
