options:
  parameters:
    generate_options: qt_gui
    id: QPSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Fc
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: Fs
  id: variable
  parameters:
    value: 4 * Fc
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '64'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[numpy.exp(1j*2*numpy.pi*k/8) for k in range(8)]'
  states: {}
- name: mod1_0
  id: mod1
  parameters: {}
  states: {}
- name: new_hier_0
  id: new_hier
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    note: 4 périodes par symbole
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: symbol_rate < Fc*2
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: samp_rate / symbol_rate
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: Fs > 2 * Fc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Time Sink Partie I et Q
    size: '8192'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Symboles (Sources12-Entree, Sources34-Après Démodulation )
    nconnections: '2'
    size: '8192'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [analog_sig_source_x_0, '0', mod1_0, '0']
- [analog_sig_source_x_0, '0', new_hier_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', mod1_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0, '0']
- [mod1_0, '0', blocks_throttle2_0, '0']
- [mod1_0, '0', new_hier_0, '1']
- [mod1_0, '0', qtgui_time_sink_x_0, '0']
- [mod1_0, '1', qtgui_time_sink_x_0_0, '0']
- [new_hier_0, '0', qtgui_time_sink_x_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
